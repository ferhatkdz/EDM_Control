# Keil uVision project EDM_Control.uvprojx, settings and files
target M483SE8AE (6240000::V6.24::ARMCLANG)
  device: M483SE8AE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: EDM_Main_v100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: M480 M483SE8AE M4
  c include: .\inc;.\src\bsp;.\src\usb;.\bsp_hal\inc;.\M480BSP\Library\CMSIS\Include;.\M480BSP\Library\StdDriver\inc;.\M480BSP\Library\Device\Nuvoton\M480\Include;.\qpc\include;.\qpc\ports\arm-cm\qk\armclang
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./src/: main.c cli.c pid.c velocity.c motor.c ark.c
  group bsp
    ./src/bsp/: bsp.c bsp.h
  group bsp_hal
    ./bsp_hal/src/: pinmap_common.c bsp_hal_nu_m480.c
  group startup
    ./src/startup/: startup_M480.s system_M480.c
  group hal
    ./M480BSP/Library/StdDriver/src/: clk.c gpio.c timer.c retarget.c epwm.c eadc.c qei.c uart.c sys.c usbd.c spi.c
  group qp
    ./qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ./qpc/src/qk/: qk.c
  group qp_port
    ./qpc/ports/arm-cm/qk/armclang/: qk_port.c
  group libs
    ./: M480_vcom_lib.lib
